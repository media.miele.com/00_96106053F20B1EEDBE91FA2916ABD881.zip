Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-05-08T10:46:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 08 10:46:55 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\628cfd45-d802-40c7-a785-9cf8a57df9e1\ed75301f-fec9-4638-a217-4925832f9489\ifc * Database version: 5507 * Database creation date: Mon May 08 10:46:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 08 10:46:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 08 10:46:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11990800_EU1_K7216E:36721605_EU1_11990800_K7216E, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 36721605_EU1_11990800_K7216E
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 36721605_EU1_11990800_K7216E
Type - Pset_ProvisionForVoid - Width: 558 mm; Height: 1221 mm; Depth: 545 mm
Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Connection_Connection_Modul, z_Miele_Design_Cast, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
